SRC_URI += "file://user_2019-01-15-15-31-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

