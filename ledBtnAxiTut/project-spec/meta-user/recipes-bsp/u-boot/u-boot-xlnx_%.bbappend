SRC_URI_append = " file://platform-top.h"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://user_2018-12-26-14-15-00.cfg \
            file://user_2018-12-26-14-34-00.cfg \
            "

