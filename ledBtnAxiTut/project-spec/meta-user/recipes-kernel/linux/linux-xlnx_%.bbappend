SRC_URI += "file://user_2018-12-14-23-35-00.cfg \
            file://user_2018-12-26-14-05-00.cfg \
            file://user_2018-12-26-14-32-00.cfg \
            "

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

